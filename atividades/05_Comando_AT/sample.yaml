## atividades/05_Comando_AT/sample.yaml
```yaml
sample:
  name: BB micro:bit atividade_05
tests:
  test:
    platform_whitelist: bbc_microbit
    tags: samples
```
